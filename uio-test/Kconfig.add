## uio-test/Kconfig.add
```kconfig
config UIO_TEST
	tristate "UIO testing driver"
	help
          UIO testing driver
```
